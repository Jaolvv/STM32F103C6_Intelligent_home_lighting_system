# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\OBJ;..\SYSTEM\sys;..\SYSTEM\delay;..\HARDWARE\LED;..\HARDWARE\TIM;..\HARDWARE\ADC;..\HARDWARE\1602;..\HARDWARE\DH11;..\HARDWARE\RTC;..\HARDWARE\ccs811;..\HARDWARE\USART;..\HARDWARE\WSR18B20
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../OBJ/: startup_stm32f10x_md.s
    ../SYSTEM/sys/: sys.c
  group MI
    ../OBJ/: main.c
  group HARDWARE
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/1602/: lcd1602.c
